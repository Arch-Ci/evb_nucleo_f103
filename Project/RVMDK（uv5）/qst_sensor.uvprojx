# Keil uVision project qst_sensor.uvprojx, settings and files
target qst_sensor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qst_evb +hex
  AfterMake: $KARM\ARMCC\bin\fromelf --bin --output="$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD SYSCLK_USE_HSI USE_STDPERIPH_DRIVER ST_NUCLEO_BOARD USE_I2C_1_PB8_9 QST_USE_SW_I2C
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\i2c;..\..\User\spi;..\..\User\usart;..\..\User\qmaX981;..\..\User\qmc6308;..\..\User\qmcX983;..\..\User\qmp6988;..\..\User\qmi8610;..\..\User\px318j;..\..\User\SysTick;..\..\User\flash;..\..\User\Led;..\..\User\qma6100;..\..\User\qmi8658;..\..\User\sd1306;..\..\algo\fusion;..\..\algo\MagCali;..\..\algo\compass;..\..\upper
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart.c
    ../../User/i2c/: bsp_i2c.c qst_sw_i2c.c
    ../../User/rtc/: bsp_rtc.c bsp_date.c bsp_calendar.c
    ../../User/qmaX981/: qmaX981.c qmaX981_algo.c
    ../../User/qmcX983/: qmcX983.c
    ../../User/spi/: bsp_spi.c
    ../../User/qmp6988/: qmp6988.c
    ../../User/qmc6308/: qmc6308.c
    ../../User/px318j/: px318j.c
    ../../User/flash/: bsp_flash.c
    ../../User/qma6100/: qma6100.c
    ../../User/qmi8610/: qmi8610.c
    ../../User/qmi8658/: qmi8658.c
    ../../User/sd1306/: sd1306.c
  group DOC
    ../../Doc/: readme.txt
  group fusion
    ../../algo/fusion/: qst_lib_fusion.lib
  group upper
    ../../upper/: qst_packet.c
  group magcali
    ../../algo/compass/: qst_lib_compass.lib
